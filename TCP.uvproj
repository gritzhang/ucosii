# Keil uVision project TCP.uvproj, settings and files
target ReleasInFlash (ARM-ADS)
  device: LPC1778 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1700 +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c misc: --C99
  c include: .\LCP1778Ports\include;.\CM3;.\LPC17xx;.\USER_CODE;.\uCOS-II\Source;.\uCOS-II\Ports;.\CM3;.\LPC177x_8x;..\1129_LPC1778_MCU;.\LPC177x_8x\Startup;.\uCOS-II;.\uCOS-II\Ports;.\uCOS-II\Source;.\USER_CODE;.\uCOS-II\zy_if;.\uCOS-II\Source;.\USER_CODE;.\MoudleAPI\t6963;.\global;.\MoudleAPI\w5100;.\MoudleAPI\PCF8563;.\USER_CODE\rtc;.\USER_CODE\PTL104;.\MoudleAPI\fram;.\MoudleAPI\FM1702;.\MoudleAPI\rs232;.\MoudleAPI\relay;.\USER_CODE\ADC;.\USER_CODE\charge_deal;.\MoudleAPI\dl645a;.\QRCodes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\LPC177x_8x.sct
  group App Code
    ./USER_CODE/: main.c lcd.c Hardware_Interface.c it_isr.c ethernet.c
    ./global/: global.c
    ./USER_CODE/rtc/: rtc.c
    ./USER_CODE/ADC/: lpc_adc.c
    ./USER_CODE/charge_deal/: charge_station_deal.c
    ./USER_CODE/PTL104/: PTL104.c
  group uCOS-II
    ./uCOS-II/Source/: OS_TIME.C OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C
  group OS_PORTS
    ./uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group MoudleAPI
    ./MoudleAPI/t6963/: t6963.c
    ./MoudleAPI/w5100/: w5100.c socket.c
    ./MoudleAPI/PCF8563/: PCF8563.c
    ./MoudleAPI/fram/: fram.c
    ./MoudleAPI/FM1702/: FM1702.c
    ./MoudleAPI/relay/: relay.c
    ./MoudleAPI/rs232/: rs232.c
    ./MoudleAPI/dl645a/: dl645a.c
    ./MoudleAPI/debug/: uart1.c
  group LPC1778Ports
    ./LCP1778Ports/source/: lpc177x_8x_ssp.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_gpio.c lpc177x_8x_nvic.c lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c
  group CMSIS Files
    ./CM3/: core_cm3.c
    ./LPC177x_8x/: system_LPC177x_8x.c
    ./LPC177x_8x/Startup/: startup_LPC177x_8x.s
  group QRCodes
    ./QRCodes/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
